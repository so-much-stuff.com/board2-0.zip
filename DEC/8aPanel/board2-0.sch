# EAGLE board board2-0 (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
N$38  (via drill 0.61) (continued)
  Top 0.254: v258.06,68.58 258.06,8.64 235.2,8.64 225.04,18.8 225.04,30.99 224.03,32 E22.5 | v314.45,68.58 316.99,71.12 316.99,72.64 E8.3
  Bottom 0.254: v258.06,68.58 v314.45,68.58
N$39  (via drill 0.61)
  Top 0.254: v135.13,5.59 135.13,9.14 132.59,11.68 E33.1 | v178.31,8.64 182.37,12.7 v182.37,31.5
  Bottom 0.254: v135.13,5.59 175.26,5.59 v178.31,8.64 | v182.37,31.5 182.88,30.99 216.92,30.99 217.93,32 E22.3
N$40
  Bottom 0.254: E32.6 145.29,34.04 146.81,35.56 213.87,35.56 215.39,34.04 E22.2
N$41  (via drill 0.61)
  Top 0.254: E22.1 213.87,34.04 218.44,38.61 219.46,38.61 219.46,79.25 220.47,80.26 E20.11 | v262.64,84.33 262.64,83.31 276.86,83.31 278.38,84.84 357.63,84.84 360.17,82.3 E4.9
  Bottom 0.254: v262.64,84.33 223.52,84.33 221.49,82.3 E20.11
N$42
  Bottom 0.254: E25.12 193.55,41.66 194.56,42.67 227.08,42.67 228.09,41.66 E22.8
N$44  (via drill 0.61)
  Top 0.254: v143.26,67.06 143.26,34.54 142.75,34.04 E32.5 | v172.21,67.06 v169.16,67.06 | v200.66,67.56 202.69,65.53 202.69,61.98 E24.8
  Bottom 0.254: v143.26,67.06 144.27,68.07 155.96,68.07 156.46,68.58 168.15,68.58 169.16,67.56 v169.16,67.06 | v172.21,67.06 194.56,67.06 195.07,67.56 v200.66,67.56
N$46
  Bottom 0.254: E36.9 122.43,22.35 140.72,22.35 141.73,21.34 E33.10
N$47  (via drill 0.61)
  Top 0.254: v199.14,23.88 199.14,59.44 198.63,59.94 E24.10
  Bottom 0.254: v199.14,23.88 199.64,24.38 217.93,24.38 220.98,21.34 E23.11
N$48  (via drill 0.61)
  Top 0.254: v152.91,19.81 155.96,16.76 155.96,14.22 158.5,11.68 163.58,11.68 163.58,39.12 163.07,39.62 E29.15
  Bottom 0.254: v152.91,19.81 147.83,19.81 E33.8
N$49  (via drill 0.61)
  Top 0.254: v160.02,26.92 160.02,32 E29.1 | v200.66,26.42 203.2,23.88 203.2,22.86 E26.10
  Bottom 0.254: v160.02,26.92 170.18,26.92 171.2,25.91 200.15,25.91 v200.66,26.42
N$50  (via drill 0.61)
  Top 0.254: 161.04,18.29 161.04,30.99 162.05,32 E29.2 | 161.04,18.29 161.04,16.26 160.02,15.24 E30.1 | v165.1,65.02 165.1,71.12 E27.3 | v184.4,64.01 186.94,61.47 186.94,50.8 189.99,47.75 189.99,41.66 E25.13 189.99,39.62 189.48,39.12 189.48,31.5 189.99,30.99 189.99,23.37 190.5,22.86 E26.15 190.5,20.32 v190.5,18.29 | 161.04,18.29 v162.56,18.29
  Bottom 0.254: v165.1,65.02 183.39,65.02 v184.4,64.01 | v162.56,18.29 v190.5,18.29
N$51  (via drill 0.61)
  Top 0.254: v165.1,28.96 165.1,32 E29.3 | E25.1 187.96,32 v187.96,28.96 187.96,22.86 E26.16
  Bottom 0.254: v165.1,28.96 v187.96,28.96
N$52
  Top 0.254: E22.4 220.47,34.04 219.96,34.54 219.96,51.82 220.47,52.32 E21.4
  Bottom 0.254: E21.3 218.95,52.32 220.47,52.32 E21.4
N$53
  Bottom 0.254: E25.8 203.71,40.64 211.84,40.64 212.34,40.13 212.34,38.61 224.54,38.61 225.55,39.62 E22.9
N$55  (via drill 0.61)
  Top 0.254: E30.10 170.18,22.86 166.12,26.92 v166.12,30.99 166.12,51.31 167.13,52.32 E28.4
  Bottom 0.254: E32.1 132.59,32 133.6,30.99 v166.12,30.99 173.74,30.99 174.75,32 E29.7
N$56  (via drill 0.61)
  Top 0.254: v147.32,29.97 148.84,31.5 v148.84,39.12 | v156.46,41.66 156.97,42.16 156.97,51.82 v157.99,52.83 | v174.75,48.26 174.75,44.2 177.29,41.66 E29.9 | v162.56,48.26 162.56,52.32 E28.2
  Bottom 0.254: v147.32,29.97 131.06,29.97 131.06,34.54 131.57,35.05 133.1,35.05 134.11,34.04 E32.2 | v148.84,39.12 151.38,41.66 v156.46,41.66 | v157.99,52.83 159,53.85 159,55.37 161.04,55.37 162.05,54.36 E28.2 | v174.75,48.26 174.24,48.77 163.07,48.77 v162.56,48.26
N$57  (via drill 0.61)
  Top 0.254: v135.13,48.26 135.13,52.32 E31.2 | v168.66,47.24 169.16,46.74 v169.16,37.59
  Bottom 0.254: v135.13,48.26 135.64,47.75 155.96,47.75 156.97,46.74 168.15,46.74 v168.66,47.24 | v169.16,37.59 170.18,38.61 173.74,38.61 174.75,39.62 E29.10
N$58  (via drill 0.61)
  Top 0.254: v172.72,57.91 173.74,56.9 173.74,42.16 173.23,41.66 E29.11
  Bottom 0.254: v172.72,57.91 172.21,57.4 161.54,57.4 161.54,61.98 160.53,62.99 148.84,62.99 147.83,61.98 E31.10
N$59
  Bottom 0.254: E32.9 145.29,39.62 146.81,38.1 168.15,38.1 169.67,39.62 E29.12
N$60  (via drill 0.61)
  Top 0.254: v158.5,41.66 159,41.15 159,12.19 161.04,12.19 162.05,13.21 E30.2
  Bottom 0.254: v158.5,41.66 159.51,42.67 | 159.51,42.67 166.12,42.67 167.13,41.66 E29.13 | 159.51,42.67 143.76,42.67 142.75,41.66 E32.10
N$61  (via drill 0.61)
  Top 0.254: v130.56,21.34 133.1,23.88 133.1,49.78 v132.59,50.29 | v165.1,50.29 165.1,41.66 E29.14
  Bottom 0.254: v130.56,21.34 131.06,21.34 131.06,18.8 131.57,18.29 135.64,18.29 136.65,19.3 E33.12 | v132.59,50.29 133.1,50.8 144.27,50.8 144.78,50.29 v165.1,50.29
N$62
  Bottom 0.254: E33.4 140.21,13.72 141.22,14.73 155.96,14.73 158.5,12.19 212.85,12.19 E23.1
N$63
  Bottom 0.254: E11.11 335.79,19.3 337.31,17.78 343.41,17.78 344.93,19.3 E7.15
N$64
  Bottom 0.254: E11.13 330.71,21.34 331.72,22.35 356.62,22.35 357.63,21.34 E7.10
N$65
  Top 0.254: E11.15 324.61,19.3 324.1,18.8 324.1,11.18 324.61,10.67 344.42,10.67 344.42,14.22 344.93,14.73 357.63,14.73 357.63,13.72 E7.7
N$66
  Top 0.254: E11.17 320.55,19.3 321.56,18.29 321.56,11.18 322.58,10.16 344.93,10.16 344.93,11.68 E7.2
N$67  (via drill 0.61)
  Top 0.254: v162.05,28.96 162.05,23.37 162.56,22.86 E30.13 | v153.92,28.96 154.43,29.46 154.43,51.31 154.94,51.82 154.94,64.01 154.43,64.52 v154.43,70.1
  Bottom 0.254: v153.92,28.96 v162.05,28.96 | v154.43,70.1 170.69,70.1 172.21,71.63 E27.6
N$68  (via drill 0.61)
  Top 0.254: v160.02,48.26 160.02,47.24 163.07,47.24 163.58,47.75 163.58,58.93 164.59,59.94 E28.14 | v157.99,48.26 158.5,47.75 158.5,46.23 162.05,42.67 164.08,42.67 164.08,26.42 167.64,22.86 E30.11
  Bottom 0.254: v157.99,48.26 v160.02,48.26
N$69
  Top 0.254: E32.3 137.67,34.04 138.18,34.54 138.18,51.31 139.19,52.32 E31.4
N$70  (via drill 0.61)
  Top 0.254: E34.1 104.65,54.36 106.17,55.88 106.17,59.94 E34.15 | 113.28,32 113.79,32 E35.5 | 113.28,32 112.27,32 E35.4 111.25,34.04 110.74,34.54 v110.74,51.31 | v172.72,10.16 172.72,12.7 E30.6 | v150.88,10.67 148.84,12.7 v148.84,21.34 | v113.28,23.37 113.28,32
  Bottom 0.254: v172.72,10.16 151.38,10.16 v150.88,10.67 | v148.84,21.34 146.81,23.37 v113.28,23.37 | v110.74,51.31 105.66,51.31 104.65,52.32 E34.1
N$71  (via drill 0.61)
  Top 0.254: 171.7,46.74 171.7,51.82 172.21,52.32 E28.6 | 171.7,46.74 171.7,31.5 172.21,30.99 172.21,23.37 172.72,22.86 E30.9 | 146.3,39.12 146.3,5.59 144.27,5.59 143.26,6.6 143.26,11.18 142.75,11.68 E33.5 | 146.3,39.12 146.81,39.62 E32.8 | 146.3,39.12 146.3,46.74 | 146.3,46.74 146.3,52.32 145.29,52.32 E31.6 | v170.18,46.74 171.7,46.74 | 146.3,46.74 v146.81,46.74
  Bottom 0.254: v170.18,46.74 169.67,46.23 147.32,46.23 v146.81,46.74
N$72
  Top 0.254: E35.10 118.87,41.66 115.32,45.21 115.32,59.44 114.81,59.94 E34.12
N$73
  Top 0.254: E35.9 121.41,41.66 117.35,45.72 117.35,52.32 E34.6
N$74  (via drill 0.61)
  Top 0.254: v142.24,70.61 142.24,61.98 E31.12
  Bottom 0.254: v142.24,70.61 142.75,71.12 159,71.12 159.51,70.61 166.12,70.61 167.13,71.63 E27.4
N$75
  Top 0.254: E4.5 352.55,74.68 347.98,79.25 341.88,79.25 341.88,80.77 339.34,83.31 326.14,83.31 326.14,79.76 325.63,79.25 323.09,79.25 323.09,80.26 E8.10
  Bottom 0.254: E8.12 318.01,80.26 319.02,79.25 321.06,79.25 322.07,80.26 E8.10
N$76  (via drill 0.61)
  Top 0.254: v120.9,62.99 120.9,59.44 122.94,57.4 122.94,37.08 120.9,35.05 120.9,4.06 156.97,4.06 164.08,11.18 164.08,11.68 165.1,12.7 E30.3
  Bottom 0.254: v120.9,62.99 135.64,62.99 136.65,61.98 E31.14
N$77  (via drill 0.61)
  Top 0.254: v162.05,65.02 162.05,70.61 162.56,71.12 E27.2 | v155.45,65.02 155.45,35.56 154.94,35.05 v154.94,20.83
  Bottom 0.254: v155.45,65.02 v162.05,65.02 | v154.94,20.83 156.97,18.8 157.99,18.8 159,19.81 163.58,19.81 164.59,20.83 E30.12
N$79
  Bottom 0.254: E10.11 335.79,39.62 337.31,38.1 343.41,38.1 344.93,39.62 E6.15
N$80
  Bottom 0.254: E10.13 330.71,41.66 331.72,42.67 356.62,42.67 357.63,41.66 E6.10
N$81  (via drill 0.61)
  Top 0.254: v355.09,43.69 357.12,41.66 357.12,34.54 357.63,34.04 E6.7
  Bottom 0.254: v355.09,43.69 327.66,43.69 325.63,41.66 E10.15
N$82  (via drill 0.61)
  Top 0.254: v344.93,36.58 344.93,34.04 E6.2
  Bottom 0.254: v344.93,36.58 331.22,36.58 330.2,37.59 322.58,37.59 320.55,39.62 E10.17
N$83
  Bottom 0.254: E9.11 335.79,60.96 341.38,60.96 341.88,60.45 341.88,58.93 343.92,58.93 344.93,59.94 E5.15
N$84
  Bottom 0.254: E9.13 330.71,61.98 331.72,62.99 356.62,62.99 357.63,61.98 E5.10
N$85  (via drill 0.61)
  Top 0.254: v345.44,58.93 345.44,54.36 E5.2
  Bottom 0.254: v345.44,58.93 344.93,58.42 339.34,58.42 338.84,58.93 321.56,58.93 320.55,59.94 E9.17
N$86  (via drill 0.61)
  Top 0.254: v326.64,50.29 326.64,58.93 325.63,59.94 E9.15
  Bottom 0.254: v326.64,50.29 327.15,50.8 356.11,50.8 357.63,52.32 E5.7
N$87
  Top 0.254: E23.9 226.57,21.34 227.08,21.84 227.08,55.88 228.09,56.9 228.09,59.94 E21.8
N$88
  Top 0.254: E4.6 356.11,74.68 358.65,77.22 367.79,77.22 C37.1 368.81,77.22 370.33,77.22 C40.1
N$89
  Top 0.254: R25.1 366.27,72.14 367.79,72.14 C37.2 368.81,72.14 370.33,72.14 C40.2
  Bottom 0.254: E4.7 358.65,72.64 359.66,71.63 365.76,71.63 R25.1
N$93
  Top 0.254: E26.8 205.74,15.24 206.76,16.26 206.76,48.26 206.25,48.77 206.25,77.72 214.88,86.36 224.54,86.36 224.54,77.72 221.49,74.68 E20.4
N$94  (via drill 0.61)
  Top 0.254: v205.23,38.61 205.23,23.37 205.74,22.86 E26.9
  Bottom 0.254: v205.23,38.61 202.18,38.61 201.17,39.62 E25.9
NUM  (via drill 0.61)
  Top 0.254: v216.92,77.72 216.92,62.48 216.41,61.98 E21.13 | v318.52,83.31 318.52,75.69 319.53,74.68 E8.4
  Bottom 0.254: 217.93,78.74 v216.92,77.72 | 217.93,78.74 239.27,78.74 240.79,80.26 E16.12 241.81,82.3 242.82,83.31 v318.52,83.31 | 217.93,78.74 217.42,78.74 217.42,82.3 216.41,83.31 212.85,83.31 210.82,81.28 176.28,81.28 175.77,81.79 159.51,81.79 159,81.28 154.43,81.28 152.4,83.31 118.36,83.31 117.35,82.3 J4.11
NUMCLK
  Top 0.254: E3.8 385.57,19.3 384.05,19.3 E3.9 384.05,21.34 384.56,21.84 384.56,39.62 | 384.56,39.62 385.57,39.62 E2.8 | 384.56,39.62 384.05,39.62 E2.9 384.05,41.66 384.56,42.16 384.56,59.94 | 384.56,59.94 385.57,59.94 E1.8 | 384.56,59.94 384.05,59.94 E1.9
  Bottom 0.254: E8.6 325.63,72.64 327.15,71.12 373.89,71.12 383.03,61.98 E1.9
PANLOCK  (via drill 0.61)
  Top 0.254: v128.52,10.67 127.51,11.68 127.51,81.79 136.65,90.93 163.58,90.93 163.58,62.48 163.07,61.98 E28.15 162.05,59.94 162.05,55.88 160.53,54.36 E28.1 | v197.61,47.75 197.61,41.66 E25.10 | v194.06,49.28 194.06,59.44 193.55,59.94 E24.12
  Bottom 0.254: v128.52,10.67 143.26,10.67 144.27,11.68 E33.6 | E24.12 192.53,59.94 191.01,58.42 174.75,58.42 174.24,58.93 172.21,58.93 171.2,57.91 164.59,57.91 162.56,59.94 E28.15 | v197.61,47.75 196.09,49.28 v194.06,49.28
PANLOCK\  (via drill 0.61)
  Top 0.254: v178.82,84.33 178.82,83.31 182.37,83.31 189.99,75.69 189.99,61.98 E24.13 | v98.55,84.84 97.54,83.82 v97.54,75.69
  Bottom 0.254: v178.82,84.33 176.28,86.87 146.81,86.87 146.3,86.36 142.24,86.36 141.73,86.87 139.19,86.87 138.68,87.38 113.79,87.38 112.27,85.85 99.57,85.85 v98.55,84.84 | v97.54,75.69 77.22,75.69 76.71,76.2 | 76.71,76.2 74.17,78.74 J2.6 | 76.71,76.2 9.65,76.2 7.11,78.74 R31.2
POWCK  (via drill 0.61)
  Top 0.254: v195.58,66.55 195.58,61.98 E24.11 | v51.31,73.66 46.23,78.74 J2.28 45.21,78.74 45.21,43.18 42.67,43.18 42.16,43.69 42.16,48.77 35.56,48.77 28.45,41.66 28.45,25.91 15.75,25.91 R33.2
  Bottom 0.254: v195.58,66.55 195.07,66.04 171.7,66.04 168.66,69.09 155.96,69.09 155.45,68.58 60.96,68.58 55.88,73.66 v51.31,73.66
PULSELOADADD\  (via drill 0.61)
  Top 0.254: v144.27,38.61 143.76,39.12 143.76,55.37 145.8,55.37 146.81,54.36 E31.7 | v91.44,41.15 84.84,47.75 v84.84,57.4 | v33.02,75.18 30.48,77.72 30.48,78.23 J2.40
  Bottom 0.254: v144.27,38.61 143.76,38.1 129.03,38.1 128.52,37.59 95,37.59 v91.44,41.15 | v84.84,57.4 78.23,64.01 44.2,64.01 v33.02,75.18
RUN\  (via drill 0.61)
  Top 0.254: 58.42,14.22 9.65,14.22 8.13,12.7 R28.1 | 58.42,14.22 58.42,37.59 J1.18 | v198.12,57.4 198.12,54.36 E24.5 | v182.37,57.4 181.36,56.39 181.36,13.21 176.28,8.13 v176.28,4.06 | v61.47,11.18 58.42,14.22
  Bottom 0.254: v198.12,57.4 v182.37,57.4 | v176.28,4.06 173.74,1.52 105.66,1.52 96.01,11.18 v61.47,11.18
SHLT\
  Bottom 0.254: J3.5 142.75,72.64 143.76,71.63 159.51,71.63 E27.1
SINGSTEP\  (via drill 0.61)
  Top 0.254: v166.62,90.93 166.62,62.48 167.13,61.98 E28.13 | v109.22,90.42 100.58,81.79 v100.58,75.69 | v65.02,74.68 63.5,76.2 63.5,78.23 J2.14
  Bottom 0.254: v166.62,90.93 165.61,91.95 110.74,91.95 v109.22,90.42 | v100.58,75.69 99.57,74.68 v65.02,74.68
SRDATA\  (via drill 0.61)
  Top 0.254: v134.62,44.2 134.62,41.66 E32.13 | v313.44,44.2 313.44,72.14 312.93,72.64 E8.1 | J2.30 43.18,78.23 41.66,76.71 41.66,64.52 13.21,36.07 R30.1 12.19,35.05 12.19,27.43 10.67,25.91 R29.2
  Bottom 0.254: 134.11,43.69 v134.62,44.2 | 134.11,43.69 7.11,43.69 5.08,41.66 5.08,37.08 11.18,37.08 12.19,36.07 R30.1 | v313.44,44.2 312.93,43.69 275.84,43.69 275.34,43.18 229.62,43.18 229.11,43.69 134.11,43.69
STATE\  (via drill 0.61)
  Top 0.254: v116.84,69.6 116.84,61.98 E34.11 | v34.54,75.18 33.02,76.71 33.02,78.23 J2.38
  Bottom 0.254: v116.84,69.6 114.81,71.63 59.94,71.63 55.88,75.69 35.05,75.69 v34.54,75.18
STHIS\
  Bottom 0.254: J3.4 140.21,74.68 141.22,75.69 186.94,75.69 188.98,73.66 211.84,73.66 212.34,74.17 212.34,75.69 214.38,75.69 215.39,74.68 E20.2
THIS  (via drill 0.61)
  Top 0.254: v170.18,66.04 170.18,61.98 E28.12 | v220.98,65.53 223.01,67.56 223.01,72.64 E20.5
  Bottom 0.254: v170.18,66.04 170.69,65.53 v220.98,65.53
TSI\  (via drill 0.61)
  Top 0.254: v217.93,62.99 217.93,72.64 E20.3 | J1.26 48.26,37.59 44.7,34.04 44.7,20.83 38.61,14.73 5.59,14.73 5.59,13.21 R27.1 | v198.12,58.93 196.6,57.4 v196.6,28.96 | v171.2,27.43 v171.2,6.6
  Bottom 0.254: E21.10 223.01,61.98 222,62.99 v217.93,62.99 202.18,62.99 201.17,61.98 E24.9 200.15,59.94 199.14,58.93 v198.12,58.93 | 9.14,11.68 9.65,12.19 R26.2 | 9.14,11.68 6.1,11.68 5.59,12.19 R27.1 | v196.6,28.96 194.56,26.92 175.26,26.92 174.24,27.94 171.7,27.94 v171.2,27.43 | v171.2,6.6 117.86,6.6 112.27,12.19 97.03,12.19 96.52,12.7 19.3,12.7 18.29,11.68 9.14,11.68
VCC  (via drill 0.61)
  Top 0.381: E33.14 131.57,19.3 130.05,19.3 C33.2 | E36.6 116.84,15.24 116.84,20.32 E36.11 116.84,22.86 116.84,32 E35.6 | J1.1 78.74,40.13 78.74,38.61 J1.2 78.23,38.1 76.71,38.1 J1.4 76.2,38.61 76.2,40.13 J1.3 75.69,40.64 74.17,40.64 J1.5 73.15,40.64 71.63,40.64 J1.7 70.61,40.64 69.09,40.64 J1.9 | E36.1 104.14,15.24 104.14,20.32 E36.16 104.14,22.86 100.08,26.92 100.08,37.08 101.6,38.61 C35.2 101.6,40.13 100.08,41.66 100.08,57.4 101.6,58.93 C34.2 101.6,60.45 101.6,78.23 103.63,80.26 J4.16 | R35.1 17.27,22.86 15.75,22.86 R34.1 14.73,22.86 13.21,22.86 R36.1 12.19,22.86 10.67,22.86 R26.1 9.65,22.86 8.13,22.86 R28.2 7.62,23.37 7.62,33.02 9.65,35.05 R29.1 10.16,36.07 10.16,52.83 8.64,54.36 VCC.1 8.64,57.4 8.64,64.01 9.65,65.02 C38.+ | R31.1 7.11,68.58 9.14,66.55 C38.+ | C39.+ 14.22,65.53 11.18,65.53 C38.+ | J2.9 69.09,81.28 70.61,81.28 J2.7 71.63,81.28 73.15,81.28 J2.5 74.17,81.28 75.69,81.28 J2.3 76.71,81.28 78.23,81.28 J2.1 | E27.14 159.51,79.25 157.99,79.25 C27.2 | 131.06,79.76 129.54,78.23 129.54,60.45 C31.2 | 131.06,79.76 131.57,80.26 J3.16 | v132.08,78.23 131.06,79.25 131.06,79.76 | 155.96,29.97 155.96,35.05 157.48,36.58 157.48,38.61 C29.2 | 155.96,29.97 155.96,21.84 156.97,20.83 C30.2 | v175.77,37.59 175.77,36.58 173.23,34.04 E29.6 173.23,32 v173.23,29.97 | E25.14 187.96,41.66 187.96,45.72 183.9,49.78 183.9,55.37 184.4,55.88 184.4,57.91 185.42,58.93 C24.2 185.42,60.45 185.42,61.47 v182.88,64.01 | v157.99,29.97 155.96,29.97 | C19.2 234.19,19.3 235.71,19.3 E19.16 235.71,21.34 232.16,24.89 232.16,37.08 | E18.16 235.71,39.62 234.19,39.62 C18.2 233.68,38.61 232.16,37.08
  Top 0.381: 232.16,37.08 232.16,57.4 233.68,58.93 C17.2 234.19,59.94 235.71,59.94 E17.16 235.71,61.98 232.16,65.53 232.16,77.72 233.68,79.25 C16.2 234.19,80.26 235.71,80.26 E16.14 236.73,82.3 237.74,83.31 245.87,83.31 245.87,82.3 E16.10 245.87,80.26 245.87,76.2 244.35,74.68 E16.4 | v200.66,18.29 200.66,17.78 198.12,15.24 E26.5 | C22.2 211.33,39.62 212.85,39.62 E22.14 212.85,41.66 209.3,45.21 | 209.3,45.21 209.3,57.4 210.82,58.93 C21.2 211.33,59.94 212.85,59.94 E21.14 212.85,61.98 209.3,65.53 209.3,77.72 210.82,79.25 C20.2 211.33,80.26 212.85,80.26 E20.14 213.87,82.3 213.87,83.31 222,83.31 223.01,82.3 E20.10 | 209.3,45.21 209.3,21.34 210.82,19.81 C23.2 | E3.14 370.33,19.3 368.81,19.3 C3.2 368.3,19.81 365.76,22.35 365.76,36.07 366.78,37.08 | E2.14 370.33,39.62 368.81,39.62 C2.2 368.3,38.61 366.78,37.08 | 366.78,37.08 366.78,57.4 368.3,58.93 C1.2 | C7.2 340.87,19.3 342.39,19.3 E7.16 342.39,21.34 338.84,24.89 338.84,37.08 340.36,38.61 C6.2 340.87,39.62 342.39,39.62 E6.16 342.39,41.66 338.84,45.21 338.84,56.9 | 340.36,69.6 342.39,69.6 342.9,69.09 342.9,61.98 E5.16 | 340.36,69.6 340.36,60.45 C5.2 340.36,58.93 338.84,57.4 338.84,56.9 | E4.11 356.11,80.26 357.63,80.26 E4.10 | 340.36,69.6 338.84,71.12 338.84,77.72 340.36,79.25 C4.2 | E1.14 371.35,61.98 372.36,62.99 372.36,78.23 368.3,82.3 366.27,82.3 R25.2 | 298.7,65.02 297.18,65.02 297.18,64.01 R16.2 | 298.7,65.02 300.23,65.02 301.75,63.5 R15.2 302.26,64.01 302.26,65.02 305.31,65.02 309.88,60.45 C9.2 309.88,58.93 308.36,57.4 308.36,42.16 | 298.7,65.02 298.7,79.76 297.69,80.77 R32.1 | 305.31,24.38 309.88,19.81 C11.2
  Top 0.381: 305.31,24.38 302.26,24.38 302.26,23.37 R9.2 | v292.1,20.83 292.1,13.21 R11.2 | E14.16 263.65,39.62 262.13,39.62 C14.2 261.62,38.61 260.1,37.08 260.1,21.84 261.11,20.83 C15.2 | 302.26,42.16 299.21,42.16 297.69,40.64 R6.2 | 302.26,42.16 302.26,41.15 R5.2 | v288.54,37.59 288.54,38.61 287.02,40.13 R7.2 | v292.1,37.59 292.1,40.13 R8.2 | 308.36,42.16 309.88,42.16 309.88,40.13 C10.2 | 308.36,42.16 306.32,42.16 | 306.32,42.16 302.26,42.16 | 305.31,24.38 306.32,25.4 306.32,42.16 | v337.82,56.9 338.84,56.9 | C12.2 261.11,78.23 260.1,77.22 260.1,61.98 261.62,60.45 C13.2 | v160.02,64.01 160.02,61.98 E28.16
  Bottom 0.381: C33.2 129.03,19.3 128.52,19.81 118.36,19.81 117.35,20.83 E36.11 116.33,20.83 115.32,19.81 110.24,19.81 | 110.24,19.81 111.25,20.83 E36.13 | 104.14,19.81 102.11,19.81 C36.2 | 104.14,19.81 110.24,19.81 | E32.14 131.57,39.62 130.05,39.62 C32.2 129.03,39.12 128.52,38.61 101.6,38.61 C35.2 | E35.16 103.63,39.62 102.11,39.62 C35.2 | 104.14,19.81 104.14,20.32 E36.16 | J1.1 79.25,40.64 80.26,41.66 82.8,41.66 83.31,42.16 98.55,42.16 101.09,39.62 C35.2 | R29.1 10.67,35.05 11.68,34.04 13.72,34.04 14.73,35.05 R33.1 | C34.2 102.11,59.94 103.63,59.94 E34.16 104.65,59.94 105.66,58.93 120.9,58.93 | J2.1 79.25,81.28 80.77,82.8 103.12,82.8 103.63,82.3 J4.16 | E28.16 159.51,59.94 157.99,59.94 C28.2 156.97,59.44 156.46,58.93 129.54,58.93 | 120.9,58.93 119.89,59.94 E34.10 | 129.54,58.93 120.9,58.93 | 129.54,58.93 C31.2 | E31.16 131.57,59.94 130.05,59.94 C31.2 | 129.54,58.93 C31.2 | v132.08,78.23 156.97,78.23 C27.2 | R31.1 6.1,69.09 6.1,77.22 5.59,77.22 5.08,77.72 5.08,82.8 16.26,82.8 17.27,83.82 65.53,83.82 68.07,81.28 J2.9 | E30.14 159.51,20.83 157.99,20.83 C30.2 | E29.16 159.51,39.62 157.99,39.62 C29.2 | E24.14 187.45,59.94 185.93,59.94 C24.2 | v175.77,37.59 176.78,38.61 185.42,38.61 C25.2 185.93,39.62 187.45,39.62 E25.14 188.47,39.62 190.5,37.59 208.79,37.59 210.31,39.12 C22.2 | v173.23,29.97 v157.99,29.97 | E23.14 212.85,19.3 211.33,19.3 C23.2 210.31,18.8 201.17,18.8 v200.66,18.29 200.15,18.29 199.14,19.3 186.44,19.3 185.93,19.81 C26.2 | E12.16 263.65,79.25 262.13,79.25 C12.2 261.11,78.74 248.41,78.74 246.89,80.26 E16.10 | E20.10 224.03,82.3 225.04,83.31 230.12,83.31 233.17,80.26 C16.2
  Bottom 0.381: E1.14 370.33,59.94 368.81,59.94 C1.2 | C4.2 340.87,80.26 342.39,80.26 E4.16 343.41,82.3 344.42,83.31 359.66,83.31 | 359.66,83.31 364.74,83.31 365.25,82.8 R25.2 | 359.66,83.31 358.65,82.3 E4.10 | E8.14 311.91,80.26 310.39,80.26 C8.2 309.37,80.26 298.2,80.26 297.69,80.77 R32.1 | C9.2 310.39,59.94 311.91,59.94 E9.20 312.93,59.94 315.98,56.9 v337.82,56.9 | C13.2 262.13,59.94 263.65,59.94 E13.16 264.67,61.98 266.19,63.5 286.51,63.5 R13.2 287.53,63.5 289.05,61.98 290.07,61.98 | 290.07,61.98 291.59,63.5 R14.2 | 290.07,61.98 295.15,61.98 296.67,63.5 R16.2 | R12.2 287.53,12.7 289.05,11.18 290.07,11.18 291.59,12.7 R11.2 | E11.20 311.91,19.3 310.39,19.3 C11.2 | 299.21,21.34 297.69,22.86 R10.2 | 299.21,21.34 300.23,21.34 301.75,22.86 R9.2 | v292.1,20.83 292.61,21.34 299.21,21.34 | E15.16 263.65,20.83 262.13,20.83 C15.2 | E10.20 311.91,39.62 310.39,39.62 C10.2 309.37,39.12 307.85,37.59 v292.1,37.59 v288.54,37.59 266.7,37.59 264.67,39.62 E14.16 | v182.88,64.01 v160.02,64.01

## Text on the board
Top: CEM/VRS | PDP-8/A Console, Board 2
Bottom: CEM/VRS | PDP-8/A Console, Board 2
tValues: A | VV | A | VV | CEM/VRS | PDP-8/A Console, Board 2